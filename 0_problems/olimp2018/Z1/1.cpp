/*
Завдання 1. “Закодоване повідомлення” (100 балів)

Петрик вирішив закодувати повідомлення для свого найкращого друга Тарасика. Це повідомлення він написав одним реченням. Воно складається із слів, що є послідовностями із символів-букв або символів-цифр. Окремі слова відокремлюються одне від одного довільною кількістю пропусків або розділовими знаками кома ( , ), тире ( - ), двокрапка ( : ), або їх довільними комбінаціями. Речення закінчується одним із розділових знаків: крапка ( . ), знак оклику ( ! ), знак питання ( ? ). Речення не може бути порожнім, тобто воно містить хоча б одне слово. Довжина речення вважається необмеженою. Кількість слів у реченні – це кількість нових книг, які подарували Петрику, а кількість символів у найдовшому слові – кількість нових електронних книг, які з’явились у колекції Петрика.
Скласти програму, яка встановить загальну кількість слів у реченні та знайде найбільшу довжину слова.

Вимоги до програми
Програма повинна зчитувати вхідні дані із файлу TASK1.DAT. В єдиному рядку цього файлу вказується послідовність символів, що є заданим реченням. Коректність запису речення гарантована і перевіряти її не потрібно! Знак «тире» набирається знаком «дефіс» на клавіатурі з пропусками зліва та справа.
Результат виконання програми повинен записуватися у вихідний файл TASK1.REZ. Для кожного окремого тесту в одному рядку вказується через один пропуск два цілих числа – шукана кількість слів у реченні та максимальна довжина слова.

Приклади

TASK1.DAT														 TASK1.REZ
-----------------------------------------------------------		 ----------------

Сьогодні – 23 листопада  2018 року.	                             5   9
-----------------------------------------------                  -------
Today - 23 leaflets in 2018. 				 					 5   8
*/

#include <iostream>
#include <fstream>
#include <string>
#include <vector>

using namespace std;

int main() {
	ifstream fin;
	ifstream check;
	ofstream fout;

	fin.open("TASK1.DAT", ios_base::in);
	check.open("TASK1.REZ", ios_base::in);
	fout.open("TASK11.REZ", ios_base::trunc);

	char c;
	string s;
	int vecPos = 0;
	vector<string> v;
	v.push_back(string());

	while (true) {
		fin.get(c);
		if (c == '.' || c == '!' || c == '?')
			break;

		if (c == ' ' || c == ',' || c == '-' || c == ':' || c == ';') {
			v.push_back(string());
			++vecPos;
			cout << endl;
		}
		else {
			v[vecPos].push_back(c);
			cout << c;
		}
	}

	int max = 0, cnt = 0;
	for (int i = 0; i <= vecPos; ++i) {
		if (v[i].length() != 0) 
			++cnt;
		if (v[i].length() > v[max].length())
			max = i;
	}

	cout << endl;
	cout << cnt << ' ' << v[max].length();
	fout << cnt << ' ' << v[max].length();

	check >> cnt >> max;
	cout << endl;
	cout << cnt << ' ' << max;

	fin.close();
	fout.close();
	check.close();

	cin >> c;

	return 0;
}